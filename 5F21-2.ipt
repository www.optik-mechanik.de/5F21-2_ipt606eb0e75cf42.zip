# Autodesk Inventor part: 5F21-2-internetui
## iProperties
Created: 2010-01
Part Number: 5F21-2-internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
